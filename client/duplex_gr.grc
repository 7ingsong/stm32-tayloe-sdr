options:
  parameters:
    author: singsong
    generate_options: qt_gui
    id: duplex_gr
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate_mic
  id: variable
  parameters:
    value: 11e3
  states: {}
- name: samp_rate_rx
  id: variable
  parameters:
    value: '142857'
  states: {}
- name: samp_rate_rx2
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: samp_rate_tx
  id: variable
  parameters:
    value: '64000'
  states: {}
- name: value
  id: variable_qtgui_range
  parameters:
    start: '-samp_rate_tx//2'
    step: '10'
    stop: samp_rate_tx//2
    value: '0'
  states: {}
- name: values_freq
  id: variable_qtgui_range
  parameters:
    start: '-samp_rate_rx//2'
    step: '1'
    stop: samp_rate_rx//2
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: value
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_mic
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate_mic
  states: {state: disabled}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /Users/singsong/projects/public/stm32-adc-iq/client/hussein_got_im.wav
    repeat: 'True'
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 3e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate_rx
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 3e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate_tx
    type: fir_filter_ccf
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '2002'
    type: complex
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: '2001'
    server: 'True'
    type: complex
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: samp_rate_rx2/samp_rate_rx
    type: ccf
  states: {}
- name: pfb_arb_resampler_xxx_0_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: samp_rate_tx/samp_rate_mic
    type: ccf
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate_rx
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_tx
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [audio_source_0, '0', hilbert_fc_0, '0']
- [blocks_complex_to_imag_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', pfb_arb_resampler_xxx_0_0, '0']
- [blocks_wavfile_source_0, '0', hilbert_fc_0, '0']
- [hilbert_fc_0, '0', blocks_multiply_xx_0, '0']
- [low_pass_filter_0, '0', pfb_arb_resampler_xxx_0, '0']
- [low_pass_filter_0_0, '0', network_tcp_sink_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [network_tcp_source_0, '0', low_pass_filter_0, '0']
- [network_tcp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_complex_to_imag_0, '0']
- [pfb_arb_resampler_xxx_0_0, '0', low_pass_filter_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
