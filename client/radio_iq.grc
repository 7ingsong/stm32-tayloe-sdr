options:
  parameters:
    author: singsong
    generate_options: qt_gui
    id: radio_iq
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '64000'
  states: {}
- name: samp_rate2
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: values_freq
  id: variable_qtgui_range
  parameters:
    start: '-samp_rate//2'
    step: '1'
    stop: samp_rate//2
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: values_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters:
    maxoutbuf: '2048'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    maxoutbuf: '2048'
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 3e3
    decim: '1'
    gain: '1'
    maxoutbuf: '2048'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    maxoutbuf: '2048'
    notify_missed: 'False'
    payloadsize: '512'
    port: '2001'
    src_zeros: 'False'
    type: complex
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    maxoutbuf: '2048'
    nfilts: '32'
    rrate: samp_rate2/samp_rate
    type: ccf
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_imag_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', pfb_arb_resampler_xxx_0, '0']
- [network_udp_source_0, '0', blocks_multiply_xx_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_complex_to_imag_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
